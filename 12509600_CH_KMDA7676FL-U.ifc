Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-11-29T16:16:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 29 16:16:58 2023 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\925284f6-4e53-47cf-ab30-a32816bac78e\ac1932d6-18a6-440f-9419-66a55857126f\ifc * Database version: 5507 * Database creation date: Wed Nov 29 16:16:57 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 29 16:16:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 29 16:16:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12509600_CH_KMDA7676FL-U:26767679_CH_12509600_KMDA7676FL-U, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26767679_CH_12509600_KMDA7676FL-U
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26767679_CH_12509600_KMDA7676FL-U
Material: z_Miele_Design_CLST, z_Miele_Design_print, z_Miele_Design_OBSW, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
